options:
  parameters:
    author: bgelb
    generate_options: no_gui
    id: phase
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '64'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(-gain/10)
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phi
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: '''combined_''+outfile'
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: infile
  id: parameter
  parameters:
    type: str
    value: in.wav
  states: {}
- name: outfile
  id: parameter
  parameters:
    type: str
    value: out.wav
  states: {}
- name: phi
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_stream_demux_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_2, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0, '0', blocks_multiply_const_xx_2, '0']
- [blocks_stream_demux_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_stream_demux_0, '1', blocks_phase_shift_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
