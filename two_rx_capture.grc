options:
  parameters:
    author: Ben Gelb
    description: Capture two streams of samples from sdrDUO
    generate_options: no_gui
    id: two_rx_capture
    output_language: python
    title: Two RX Capture Graph
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '125'
  states: {}
- name: f_if
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 7038.6e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: samp_rate/decim
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: samp_rate/decim
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: int(samp_rate/decim)
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import time
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, period=120, duration=118):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Periodic Burst Tagger',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period=period
              self.duration=duration
              self.in_burst=False

          def write_burst_tag(self, state):
              key = pmt.intern('burst')
              value = pmt.from_bool(state)
              self.add_item_tag(0, self.nitems_written(0), key, value)

          def write_rxtime_tag(self, tv):
              sec = int(tv)
              frac = tv % 1
              key = pmt.intern('rx_time')
              value = pmt.make_tuple(pmt.from_uint64(sec), pmt.from_double(frac))
              self.add_item_tag(0, self.nitems_written(0), key, value) 

          def work(self, input_items, output_items):
              now = time.time()
              if (now % self.period < self.duration) and not self.in_burst:
                  self.in_burst = True
                  self.write_burst_tag(True)
                  self.write_rxtime_tag(now)
              elif (now % self.period >= self.duration) and self.in_burst:
                  self.in_burst = False
                  self.write_burst_tag(False)
                  self.write_rxtime_tag(now)

              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    duration: '118'
    period: '120'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_if+bw/2
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_if+bw/2
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: fc-f_if
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'True'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '40'
    if_gRdB1: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_gR0: '0'
    rf_gR1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (diversity reception)
    sample_rate: samp_rate
    sample_rate_non_single_tuner: 2000e3
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'False'
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', blocks_stream_mux_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_stream_mux_0, '0', blocks_tag_debug_0, '0']
- [blocks_stream_mux_0, '0', blocks_tagged_file_sink_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_freqshift_cc_0_0, '0']
- [sdrplay3_rspduo_0, '0', epy_block_0, '0']
- [sdrplay3_rspduo_0, '1', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
