options:
  parameters:
    author: Ben Gelb
    description: Capture two streams of samples from sdrDUO
    generate_options: no_gui
    id: two_rx_capture
    output_language: python
    title: Two RX Capture Graph
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '125'
  states: {}
- name: f_if
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 474.2e3
  states: {}
- name: fc_2200
  id: variable
  parameters:
    value: 136e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_0_1
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_0_1_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: 12e3
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: 12e3
  states: {}
- name: blocks_freqshift_cc_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: 12e3
  states: {}
- name: blocks_freqshift_cc_0_0_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: bw/2
    sample_rate: 12e3
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '64'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '64'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '64'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: '64'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1_1
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(-gain/10)
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phi
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import time
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, period=120):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add Timestamp Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period=period
              self.last_time=None

          def write_rxtime_tag(self, tv):
              sec = int(tv)
              frac = tv % 1
              key = pmt.intern('rx_time')
              value = pmt.make_tuple(pmt.from_uint64(sec), pmt.from_double(frac))
              self.add_item_tag(0, self.nitems_written(0), key, value) 

          def work(self, input_items, output_items):
              now = time.time()
              if self.last_time and (now // self.period != self.last_time // self.period):
                  self.write_rxtime_tag(now)
              self.last_time = now

              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    period: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      import time
      from datetime import datetime
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, period_sec=120, debug=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Rotating File Sink',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period_sec = period_sec
              self.outfile = None
              self.debug = debug
              self.last_rx_time = None

          def __exit__(self, *args):
              if self.outfile:
                  print('{}: Closing current output file (shutdown).'.format(datetime,now))
                  self.outfile.close()

          def is_period_start(self, last_ts, cur_ts):
              if last_ts:
                  last_period = last_ts[0] // self.period_sec
                  cur_period = cur_ts[0] // self.period_sec
                  assert cur_period >= last_period
                  if cur_period > last_period:
                      return True
              return False

          def update_last_rx_time(self, cur_ts):
              if cur_ts:
                  self.last_rx_time = cur_ts

          def work(self, input_items, output_items):

              time_pos_list = [(None, self.last_rx_time)]

              # find all rx_time tags in input
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  offset = tag.offset
                  pos = offset - self.nitems_read(0)
                  assert pos < (self.nitems_read(0) + len(input_items[0]))
                  if key == 'rx_time':
                      if self.debug:
                          print ('{} => {}'.format(pos, value))
                      time_pos_list.append((pos, value))

              # find all period start boundaries
              start_pos = None
              for i in range(1, len(time_pos_list)):
                  if self.is_period_start(time_pos_list[i-1][1], time_pos_list[i][1]):
                      # check there aren't multiple starts
                      assert start_pos == None
                      start_pos = time_pos_list[i]

              self.update_last_rx_time(time_pos_list[-1][1])

              if start_pos:
                  period_name = datetime.fromtimestamp(start_pos[1][0]).strftime("%y%m%d_%H%M")
                  cur_file_items = input_items[0][:start_pos[0]]
                  new_file_items = input_items[0][start_pos[0]:]

                  # write out items for current file
                  if self.outfile:
                      self.outfile.write(cur_file_items.tobytes())
                      print('{}: Closing current output file.'.format(datetime.now()))
                      self.outfile.close()

                  # write out items for new file
                  filename = period_name + '.dat'
                  print ('{}: New period start at sample {} (ts={:.8f}), opening new output file {}.'.format(datetime.now(), start_pos[0]+self.nitems_read(0), start_pos[1][0]+start_pos[1][1], filename))
                  self.outfile = open(filename, 'wb')
                  self.outfile.write(new_file_items.tobytes())

              elif self.outfile:
                  self.outfile.write(input_items[0].tobytes())

              return len(input_items[0])
    debug: 'False'
    period_sec: '60'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      import time
      from datetime import datetime
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, period_sec=120, debug=False, name_prefix=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Rotating File Sink',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.period_sec = period_sec
              self.outfile = None
              self.debug = debug
              self.last_rx_time = None
              self.name_prefix = name_prefix

          def __exit__(self, *args):
              if self.outfile:
                  print('{}: Closing current output file (shutdown).'.format(datetime,now))
                  self.outfile.close()

          def is_period_start(self, last_ts, cur_ts):
              if last_ts:
                  last_period = last_ts[0] // self.period_sec
                  cur_period = cur_ts[0] // self.period_sec
                  assert cur_period >= last_period
                  if cur_period > last_period:
                      return True
              return False

          def update_last_rx_time(self, cur_ts):
              if cur_ts:
                  self.last_rx_time = cur_ts

          def work(self, input_items, output_items):

              time_pos_list = [(None, self.last_rx_time)]

              # find all rx_time tags in input
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key)
                  value = pmt.to_python(tag.value)
                  offset = tag.offset
                  pos = offset - self.nitems_read(0)
                  assert pos < (self.nitems_read(0) + len(input_items[0]))
                  if key == 'rx_time':
                      if self.debug:
                          print ('{} => {}'.format(pos, value))
                      time_pos_list.append((pos, value))

              # find all period start boundaries
              start_pos = None
              for i in range(1, len(time_pos_list)):
                  if self.is_period_start(time_pos_list[i-1][1], time_pos_list[i][1]):
                      # check there aren't multiple starts
                      assert start_pos == None
                      start_pos = time_pos_list[i]

              self.update_last_rx_time(time_pos_list[-1][1])

              if start_pos:
                  period_name = datetime.fromtimestamp(start_pos[1][0]).strftime("%y%m%d_%H%M")
                  cur_file_items = input_items[0][:start_pos[0]]
                  new_file_items = input_items[0][start_pos[0]:]

                  # write out items for current file
                  if self.outfile:
                      self.outfile.write(cur_file_items.tobytes())
                      print('{}: Closing current output file.'.format(datetime.now()))
                      self.outfile.close()

                  # write out items for new file
                  if self.name_prefix is not None:
                    filename = self.name_prefix + period_name + '.dat'
                  else:
                    filename = period_name + '.dat'
                  print ('{}: New period start at sample {} (ts={:.8f}), opening new output file {}.'.format(datetime.now(), start_pos[0]+self.nitems_read(0), start_pos[1][0]+start_pos[1][1], filename))
                  self.outfile = open(filename, 'wb')
                  self.outfile.write(new_file_items.tobytes())

              elif self.outfile:
                  self.outfile.write(input_items[0].tobytes())

              return len(input_items[0])
    debug: 'False'
    name_prefix: '''2200m_'''
    period_sec: '60'
  states: {}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      import struct

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=12000, stream_name='gnuradio', enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VBAN Audio Sink',   # will show up in GRC
                  in_sig=[np.short],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_rate = sample_rate
              self.stream_name = stream_name
              self.framecounter = 0
              self.sr_const = [6000, 12000, 24000, 48000, 96000, 192000, 384000, 8000, 16000, 32000, 64000, 128000, 256000, 512000,11025, 22050, 44100, 88200, 176400, 352800, 705600]
              self.to_ip = '192.168.2.255'
              self.to_port = 6980
              self.enabled = enabled

              # create a socket
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM) # UDP
              self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_BROADCAST, 1)

          def make_packet(self, samples, fcount):
              header  = b"VBAN" 
              header += bytes([self.sr_const.index(self.sample_rate)])
              header += bytes([len(samples)-1])
              header += bytes([0]) # mono 1 channel
              header += b'\x01'  #VBAN_CODEC_PCM
              header += bytes(self.stream_name + "\x00" * (16 - len(self.stream_name)), 'utf-8')
              header += struct.pack("<L",fcount)
              return header+samples.tobytes()

          def send_packet(self, packet):
              self.sock.sendto(packet, (self.to_ip, self.to_port))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.enabled:
                max_samples_per_packet = 255
                frames = [input_items[0][i:i+max_samples_per_packet] for i in range(0, len(input_items[0]), max_samples_per_packet)] 
                for f in frames:
                    packet = self.make_packet(f, self.framecounter)
                    self.send_packet(packet)
                    self.framecounter += 1


              return len(input_items[0])
    enabled: 'False'
    sample_rate: '12000'
    stream_name: '''630m-3'''
  states: {}
- name: epy_block_2_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      import struct

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=12000, stream_name='gnuradio', enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VBAN Audio Sink',   # will show up in GRC
                  in_sig=[np.short],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_rate = sample_rate
              self.stream_name = stream_name
              self.framecounter = 0
              self.sr_const = [6000, 12000, 24000, 48000, 96000, 192000, 384000, 8000, 16000, 32000, 64000, 128000, 256000, 512000,11025, 22050, 44100, 88200, 176400, 352800, 705600]
              self.to_ip = '192.168.2.255'
              self.to_port = 6980
              self.enabled = enabled

              # create a socket
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM) # UDP
              self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_BROADCAST, 1)

          def make_packet(self, samples, fcount):
              header  = b"VBAN" 
              header += bytes([self.sr_const.index(self.sample_rate)])
              header += bytes([len(samples)-1])
              header += bytes([0]) # mono 1 channel
              header += b'\x01'  #VBAN_CODEC_PCM
              header += bytes(self.stream_name + "\x00" * (16 - len(self.stream_name)), 'utf-8')
              header += struct.pack("<L",fcount)
              return header+samples.tobytes()

          def send_packet(self, packet):
              self.sock.sendto(packet, (self.to_ip, self.to_port))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.enabled:
                max_samples_per_packet = 255
                frames = [input_items[0][i:i+max_samples_per_packet] for i in range(0, len(input_items[0]), max_samples_per_packet)] 
                for f in frames:
                    packet = self.make_packet(f, self.framecounter)
                    self.send_packet(packet)
                    self.framecounter += 1


              return len(input_items[0])
    enabled: 'True'
    sample_rate: '12000'
    stream_name: '''2200m'''
  states: {}
- name: epy_block_2_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      import struct

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=12000, stream_name='gnuradio', enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VBAN Audio Sink',   # will show up in GRC
                  in_sig=[np.short],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_rate = sample_rate
              self.stream_name = stream_name
              self.framecounter = 0
              self.sr_const = [6000, 12000, 24000, 48000, 96000, 192000, 384000, 8000, 16000, 32000, 64000, 128000, 256000, 512000,11025, 22050, 44100, 88200, 176400, 352800, 705600]
              self.to_ip = '192.168.2.255'
              self.to_port = 6980
              self.enabled = enabled

              # create a socket
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM) # UDP
              self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_BROADCAST, 1)

          def make_packet(self, samples, fcount):
              header  = b"VBAN" 
              header += bytes([self.sr_const.index(self.sample_rate)])
              header += bytes([len(samples)-1])
              header += bytes([0]) # mono 1 channel
              header += b'\x01'  #VBAN_CODEC_PCM
              header += bytes(self.stream_name + "\x00" * (16 - len(self.stream_name)), 'utf-8')
              header += struct.pack("<L",fcount)
              return header+samples.tobytes()

          def send_packet(self, packet):
              self.sock.sendto(packet, (self.to_ip, self.to_port))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.enabled:
                max_samples_per_packet = 255
                frames = [input_items[0][i:i+max_samples_per_packet] for i in range(0, len(input_items[0]), max_samples_per_packet)] 
                for f in frames:
                    packet = self.make_packet(f, self.framecounter)
                    self.send_packet(packet)
                    self.framecounter += 1


              return len(input_items[0])
    enabled: 'True'
    sample_rate: '12000'
    stream_name: '''630m-2'''
  states: {}
- name: epy_block_2_1_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import socket
      import struct

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sample_rate=12000, stream_name='gnuradio', enabled=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='VBAN Audio Sink',   # will show up in GRC
                  in_sig=[np.short],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_rate = sample_rate
              self.stream_name = stream_name
              self.framecounter = 0
              self.sr_const = [6000, 12000, 24000, 48000, 96000, 192000, 384000, 8000, 16000, 32000, 64000, 128000, 256000, 512000,11025, 22050, 44100, 88200, 176400, 352800, 705600]
              self.to_ip = '192.168.2.255'
              self.to_port = 6980
              self.enabled = enabled

              # create a socket
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM) # UDP
              self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_BROADCAST, 1)

          def make_packet(self, samples, fcount):
              header  = b"VBAN" 
              header += bytes([self.sr_const.index(self.sample_rate)])
              header += bytes([len(samples)-1])
              header += bytes([0]) # mono 1 channel
              header += b'\x01'  #VBAN_CODEC_PCM
              header += bytes(self.stream_name + "\x00" * (16 - len(self.stream_name)), 'utf-8')
              header += struct.pack("<L",fcount)
              return header+samples.tobytes()

          def send_packet(self, packet):
              self.sock.sendto(packet, (self.to_ip, self.to_port))

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.enabled:
                max_samples_per_packet = 255
                frames = [input_items[0][i:i+max_samples_per_packet] for i in range(0, len(input_items[0]), max_samples_per_packet)] 
                for f in frames:
                    packet = self.make_packet(f, self.framecounter)
                    self.send_packet(packet)
                    self.framecounter += 1


              return len(input_items[0])
    enabled: 'False'
    sample_rate: '12000'
    stream_name: '''630m-1'''
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (fc-fc_2200)+f_if+bw/2
    decim: '125'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (fc-fc_2200)+f_if+bw/2
    decim: '125'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_if+bw/2
    decim: '125'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_if+bw/2
    decim: '125'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,bw/2,100)
    type: ccc
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '5'
  states: {}
- name: phi
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: firdes.low_pass(1.0,16e3*3,bw/2,100)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: firdes.low_pass(1.0,16e3*3,bw/2,100)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: firdes.low_pass(1.0,16e3*3,bw/2,100)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: firdes.low_pass(1.0,16e3*3,bw/2,100)
    type: ccc
  states: {}
- name: sdrplay3_rspduo_0
  id: sdrplay3_rspduo
  parameters:
    AGC: 'False'
    AGC0: 'False'
    AGC1: 'False'
    agc_set_point: '-30'
    am_notch_filter: 'False'
    antenna: Tuner 1 50 ohm
    antenna_both: Both Tuners
    bandwidth: '0'
    biasT: 'False'
    center_freq: fc_2200-f_if
    center_freq0: '0'
    center_freq1: '0'
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'True'
    freq_corr: '0'
    if_gRdB: '40'
    if_gRdB0: '47'
    if_gRdB1: '47'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_gR0: '0'
    rf_gR1: '0'
    rf_notch_filter: 'False'
    rsp_selector: ''
    rspduo_mode: Dual Tuner (diversity reception)
    sample_rate: samp_rate
    sample_rate_non_single_tuner: samp_rate
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'True'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_complex_to_real_0_0_0, '0', blocks_multiply_const_xx_1_0, '0']
- [blocks_complex_to_real_0_1, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_float_to_short_0, '0', epy_block_2_1_1, '0']
- [blocks_float_to_short_0_0, '0', epy_block_2_1_2, '0']
- [blocks_float_to_short_0_1, '0', epy_block_2_1, '0']
- [blocks_float_to_short_0_1_0, '0', epy_block_2_1_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_complex_to_real_0_0_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_xx_1_1, '0']
- [blocks_freqshift_cc_0, '0', blocks_stream_mux_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_phase_shift_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_freqshift_cc_0_0_0, '0', blocks_complex_to_real_0_1, '0']
- [blocks_freqshift_cc_0_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_freqshift_cc_0_0_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_float_to_short_0_1, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_float_to_short_0_1_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_xx_1_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_multiply_const_xx_1_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_2, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0, '0', blocks_multiply_const_xx_2, '0']
- [blocks_stream_mux_0, '0', blocks_tag_debug_0, '0']
- [blocks_stream_mux_0, '0', epy_block_1, '0']
- [blocks_stream_mux_0_0, '0', epy_block_1_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_1_1_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_1, '0', rational_resampler_xxx_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_1_1_0, '0', rational_resampler_xxx_0_0_1_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_freqshift_cc_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_freqshift_cc_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', blocks_freqshift_cc_0_0_0_0, '0']
- [sdrplay3_rspduo_0, '0', epy_block_0, '0']
- [sdrplay3_rspduo_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [sdrplay3_rspduo_0, '1', freq_xlating_fir_filter_xxx_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
