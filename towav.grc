options:
  parameters:
    author: bgelb
    generate_options: no_gui
    id: towav
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: infile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: '''ch1_''+outfile'
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: '''ch2_''+outfile'
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: infile
  id: parameter
  parameters:
    type: str
    value: in.wav
  states: {}
- name: outfile
  id: parameter
  parameters:
    type: str
    value: out.wav
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    type: ccc
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_demux_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_demux_0, '1', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_real_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
